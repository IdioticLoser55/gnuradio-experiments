options:
  parameters:
    author: idiot
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48e3)
  states: {}
- name: decim1
  id: variable
  parameters:
    value: '4'
  states: {}
- name: decim_audio
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 50e6
    step: '100'
    stop: 1.7e9
    value: 866e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '46'
  states: {}
- name: n_repeats
  id: variable
  parameters:
    value: '256'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_rate * 4
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: 5e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5e-2'
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len*n_repeats
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bins=512, n_repeats=256, sample_rate=2.4e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.complex64, n_bins * n_repeats)],
                  out_sig=[(np.float32, n_bins)]
              )
              self.n_bins = n_bins
              self.n_repeats = n_repeats
              self.sample_rate = sample_rate

          def work(self, input_items, output_items):
              s = input_items[0][0]
              s = s - s.mean()
              s.shape = (self.n_repeats, self.n_bins)
              s *= np.hamming(self.n_bins)
              psd = np.mean(np.abs(np.fft.fft(s)) ** 2, axis=0) /\
                  (self.n_bins * self.sample_rate)
              psd_log = 10 * np.log10(psd)
              psd_shifted = np.fft.fftshift(psd_log)

              output_items[0][0] = psd_shifted
              return len(output_items[0])
    n_bins: vec_len
    n_repeats: n_repeats
    sample_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Sample Rate: Doesn't matter two much what is used here.
      But is relative to cutoff freq. So better to use original. Then
      cuttoff freq is relative to original. Otherwise have to convert freq in reverse.
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e6
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: vec_len
    x_start: freq-samp_rate/2
    x_step: samp_rate/vec_len
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Highest Common Factor(2.4e6, 192e3) = 96000
      2.4e6 / 96000 = 25
      192e3 / 96000 = 2
    decim: '25'
    interp: '2'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_nbfm_rx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [low_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_throttle2_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
