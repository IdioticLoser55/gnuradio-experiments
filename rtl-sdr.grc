options:
  parameters:
    generate_options: qt_gui
    id: testing
    output_language: python
    title: RTL SDR
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    start: 24e6
    step: '1'
    stop: 1700e6
    value: 100e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '49.6'
    value: '42'
  states: {}
- name: n_repeats
  id: variable
  parameters:
    value: '256'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 0.5e6
    step: '1'
    stop: 3.2e6
    value: 2.4e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '512'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len*n_repeats
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bins=512, n_repeats=256, sample_rate=2.4e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.complex64, n_bins * n_repeats)],
                  out_sig=[(np.float32, n_bins)]
              )
              self.n_bins = n_bins
              self.n_repeats = n_repeats
              self.sample_rate = sample_rate

          def work(self, input_items, output_items):
              s = input_items[0][0]
              s = s - s.mean()
              s.shape = (self.n_repeats, self.n_bins)
              s *= np.hamming(self.n_bins)
              psd = np.mean(np.abs(np.fft.fft(s)) ** 2, axis=0) /\
                  (self.n_bins * self.sample_rate)
              psd_log = 10 * np.log10(psd)
              psd_shifted = np.fft.fftshift(psd_log)

              output_items[0][0] = psd_shifted
              return len(output_items[0])
    n_bins: vec_len
    n_repeats: n_repeats
    sample_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: vec_len
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: frequency
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
