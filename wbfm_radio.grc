options:
  parameters:
    author: idiot
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0
    start: 50e6
    step: 0.25e6
    stop: 1.7e9
    value: 95.3e6
  states: {}
- name: channel_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0
    start: '-1.6e6'
    step: '100'
    stop: 1.6e6
    value: '0'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0
    start: '0'
    step: '1'
    stop: '50'
    value: '46'
  states: {}
- name: n_repeats
  id: variable
  parameters:
    value: '32'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: int(audio_rate * audio_decim)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '256'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.05'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-channel_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: analog_wfm_rcv_1
  id: analog_wfm_rcv
  parameters:
    audio_decimation: audio_decim
    quad_rate: quad_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_rate)
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: shifts the signal source by channel offset
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len*n_repeats
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: channel_offset
    target: channel_offset
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, n_bins=256, n_repeats=32, sample_rate=2.4e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.complex64, n_bins * n_repeats)],
                  out_sig=[(np.float32, n_bins)]
              )
              self.n_bins = n_bins
              self.n_repeats = n_repeats
              self.sample_rate = sample_rate

          def work(self, input_items, output_items):
              s = input_items[0][0]
              #s = s - s.mean()
              s.shape = (self.n_repeats, self.n_bins)
              s *= np.hamming(self.n_bins)
              psd = np.mean(np.abs(np.fft.fft(s)) ** 2, axis=0) /\
                  (self.n_bins * self.sample_rate)
              psd_log = 10 * np.log10(psd)
              psd_shifted = np.fft.fftshift(psd_log)

              output_items[0][0] = psd_shifted
              return len(output_items[0])
    n_bins: vec_len
    n_repeats: n_repeats
    sample_rate: samp_rate
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import pmt

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, initial_offset=0, neg_const=-120, const=-30, n_bins=256, samp_rate=2.4e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[],
                  out_sig=[(np.float32, n_bins)]
              )

              self.const = const
              self.neg_const = neg_const
              self.n_bins = n_bins
              self.samp_rate = samp_rate

              self.bin = 0
              self.result = np.full((self.n_bins), self.neg_const)
              self.update_result(initial_offset)

              self.message_name = 'channel_offset'
              self.message_port_register_in(pmt.intern(self.message_name))
              self.set_msg_handler(pmt.intern(self.message_name), self.handle_msg)

          def handle_msg(self, msg):
              val = 0
              if pmt.is_pair(msg):
                  # key = pmt.car(msg)
                  value = pmt.cdr(msg)
                  if pmt.is_number(value):
                      val = pmt.to_double(value)

                  # print(key, val)

              self.update_result(val)

          def update_result(self, offset):
              self.result[self.bin] = self.neg_const

              self.bin = int(
                  (self.samp_rate / 2 + offset)
                  / self.samp_rate
                  * self.n_bins
              )

              self.result[self.bin] = self.const

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = self.result
              return len(output_items[0])
    const: '-30'
    initial_offset: channel_offset
    n_bins: '256'
    neg_const: '-150'
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 75e3
    decim: int(samp_rate / channel_width)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    nconnections: '2'
    vlen: vec_len
    x_start: center_freq-samp_rate/2
    x_step: samp_rate/vec_len
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '12'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: center_freq
    gain: gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', analog_wfm_rcv_1, '0']
- [analog_wfm_rcv_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_1, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_var_to_msg_0, msgout, epy_block_1, channel_offset]
- [epy_block_0, '0', qtgui_vector_sink_f_0, '1']
- [epy_block_1, '0', qtgui_vector_sink_f_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', analog_simple_squelch_cc_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
